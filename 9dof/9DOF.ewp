# IAR project 9DOF.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F10x_MD
  ICCARM.CCIncludePath2: ; Source; Libraries\CMSIS\CM3\CoreSupport; Libraries\STM32F10x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 9DOF.hex
  ILINK.IlinkOutputFile: 9DOF.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./: main_ins.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md.s
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.c
  group SOURCE
    Source/: acc_comp7.c hmc.c IIC.c ins.c Matrix.c MPU6050.c stm32f10x_it.c System_Config.c
